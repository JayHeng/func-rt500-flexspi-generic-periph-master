<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\flexspi_generic_periph_master_polling_transfer.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>flash_debug</configuration>
            </member>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>flash_release</configuration>
            </member>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_debug</name>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>flash_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_release</name>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>flexspi_octal_polling_transfer</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
